# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IR_Cam +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./List/IR_Cam.bin ./Obj/IR_Cam.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX, __FPU_PRESENT = 1, __CC_ARM, ARM_MATH_CM4
  c include: ..\libaray\inc;..\libaray\src;..\CMSIS;..\User;..\My_Lib\delay;..\My_Lib\IIC;..\My_Lib\ImageHandle;..\My_Lib\KEY;..\My_Lib\LCD;..\My_Lib\MLX90640;..\My_Lib\AD;..\My_Lib\EEPROM;..\My_Lib\USART;..\My_Lib\DMA;..\Component\RegLib\;..\My_Lib\FLASH\;..\Component\SFUD-master\others;..\Component\SFUD-master\sfud\inc;..\Component\fatfs\inc;..\OS\inc;..\Component\FatFs\option;..\Component\USB_F4\USB_APP;..\Component\USB_F4\STM32_USB_OTG_Driver\inc;..\Component\USB_F4\STM32_USB_Device_Library\Class\msc\inc;..\Component\USB_F4\STM32_USB_Device_Library\Core\inc;..\My_Lib\SYSTEM\;..\My_Lib\MEM;..\My_Lib\SPI_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../CMSIS/: startup_stm32f4xx.s
  group user
    ../User/: main.c stm32f4xx_it.c stm32f4xx.h stm32f4xx_conf.h
  group Library
    ../libaray/src/: stm32f4xx_flash.c stm32f4xx_fsmc.c misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_iwdg.c stm32f4xx_dma.c stm32f4xx_spi.c
  group CMSIS
    ../CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h system_stm32f4xx.c
  group My_Lib
    ../My_Lib/delay/: delay.c
    ../My_Lib/IIC/: MLX90640_SWI2C_Driver.c
    ../My_Lib/ImageHandle/: ImageHandle.c
    ../My_Lib/KEY/: KEY.c
    ../My_Lib/LCD/: LCD.c tft_core.c bmp.c
    ../My_Lib/AD/: AD.c
    ../My_Lib/EEPROM/: EEPROM.c
    ../My_Lib/USART/: USART.c
    ../My_Lib/DMA/: dma.c
    ../My_Lib/MLX90640/: MLX90640_API.c
    ../My_Lib/FLASH/: spi_flash_interface.c
    ../My_Lib/SYSTEM/: sys.c
    ../My_Lib/MEM/: CCM.c
    ../My_Lib/SPI_DMA/: spi_dma.c
  group SFUD
    ../Component/SFUD-master/others/: bsp.c
    ../Component/SFUD-master/sfud/port/: sfud_port.c
    ../Component/SFUD-master/sfud/src/: sfud.c sfud_sfdp.c
  group Fatfs
    ../Component/fatfs/src/: diskio.c ff.c fatfs_demo.c
    ../Component/fatfs/option/: syscall.c ccsbcs.c
  group OS
    ../OS/src/: os_global.c
  group USB_OTG
    ../Component/USB_F4/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ../Component/USB_F4/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Component/USB_F4/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_App
    ../Component/USB_F4/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usb_app.c
software components: CMSIS:CORE 5.1.2
